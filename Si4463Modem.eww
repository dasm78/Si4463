<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Si4463Modem.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\Stm8Lib.ewp</path>
  </project>
  <batchBuild/>
</workspace>


