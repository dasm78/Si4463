# IAR project Si4463Modem.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151G6 STM8L151G6
  General.GenCodeModel: 1
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: SI446X_PATCH_CMDS
  ICCSTM8.CCIncludePath2: Libraries\STM8L15x_StdPeriph_Driver\inc; inc; WDSSrc; ; Stm8Src\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Si4463Modem.bin
  ILINK.IlinkOutputFile: Si4463Modem.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenCodeModel: 0
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    Libraries/STM8L15x_StdPeriph_Driver/Debug/Exe/: Stm8Lib.a
  group Modem
    Stm8Src/: GOLAY.C main.c spi.c
  group WDSSrc
    WDSSrc/application/: radio.c
    WDSSrc/drivers/radio/: radio_comm.c radio_hal.c
    WDSSrc/drivers/radio/Si446x/: si446x_api_lib.c si446x_nirq.c
